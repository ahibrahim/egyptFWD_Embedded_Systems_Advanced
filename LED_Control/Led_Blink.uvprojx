# Keil uVision project Led_Blink.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Led_Blink
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Src\Common;.\Src\Config;.\Src\Hal\Inc;.\Src\Mcal\Dio\Inc;.\Src\Mcal\General;.\Src\Mcal\IntCtrl\Inc;.\Src\Mcal\Port\Inc;.\Src\Mcal\SysTick\Inc;.\Src\Hal\Led\Inc;.\Src\Hal\Switch\Inc;..\LED_Control
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./Src/Appl/: main.c
  group HAL
    ./Src/Hal/Led/: Led.c
  group MCAL
    ./Src/Mcal/Dio/: Dio.c
    ./Src/Mcal/IntCtrl/: IntCtrl.c
    ./Src/Mcal/Port/: Port.c
    ./Src/Mcal/SysTick/: SysTick.c
  group Config
    ./Src/Config/: IntCtrl_Lcfg.c Port_Lcfg.c SysTick_Lcfg.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
